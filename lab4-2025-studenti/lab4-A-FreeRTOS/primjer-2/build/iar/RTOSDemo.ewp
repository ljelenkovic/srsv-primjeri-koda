# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: pe550, pe144, pa039
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\common\include; ..\..\..\..\Source\include; ..\..\CMSIS; ..\..\..\..\Source\portable\IAR\ARM_CM3; ..\..\TraceRecorderConfig; ..\..\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\include; ..\..\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\kernelports\FreeRTOS\include; ..\..\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\streamports\RingBuffer\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: MPS2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: FreeRTOSConfig.h main.c
  group Blinky Demo
    ../../: main_blinky.c
  group FreeRTOS Kernel
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS Kernel/include
    ../../../../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS Kernel/Portable/IAR/ARM_CM3
    ../../../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS Kernel/Portable/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group Full Demo
    ../../: main_full.c
    ./: RegTest.S
  group Full Demo/Standard Demo Tasks
    ../../../Common/Minimal/: AbortDelay.c BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c GenQTest.c integer.c IntQueue.c IntSemTest.c MessageBufferAMP.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StaticAllocation.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
    ../../: IntQueueTimer.c
  group System files
    ./: startup_ewarm.c
  group TraceRecorder
    ../../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/: trcAssert.c trcCounter.c trcDependency.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcRunnable.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcString.c trcTask.c trcTimestamp.c
    ../../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/kernelports/FreeRTOS/: trcKernelPort.c
    ../../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/streamports/RingBuffer/: trcStreamPort.c
